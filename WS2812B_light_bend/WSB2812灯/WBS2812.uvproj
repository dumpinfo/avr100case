# Keil uVision project WBS2812.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: WBS2812 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\WSB2812灯
  asm include: ..\WSB2812灯
  group Source Group 1
    ./: STARTUP.A51 main.c WS2812_Drive.c all.h WS2812_Drive.h
