# Keil uVision project Dtion.uvprojx, settings and files
target Dotion (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Dotion_fish +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Project/Dotion_fish.bin "./Project/Dotion_fish.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Basic\delay;.\Basic\sys;.\Basic\usart;.\Basic\i2c;.\Basic\flash;.\Basic\spi;.\Basic\exti;.\Basic\time;.\Basic\id;.\Basic\dma;.\Basic\pwm;.\Hardware\LED;.\Hardware\NRF24L01;.\Hardware\OCS_ROBS251;.\Hardware\Motion_Attitude;.\Hardware\D-Bus;.\Hardware\WS2812B
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/dma/: dma.c
    ./Basic/pwm/: pwm.c
  group Hardware
    ./Hardware/WS2812B/: WS2812B.c
  group Doc
    ./Doc/: 工程目录说明.doc
software components: CMSIS:CORE 4.3.0
